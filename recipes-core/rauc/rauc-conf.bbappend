FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
RAUC_KEYRING_FILE = "ca.cert.pem"
